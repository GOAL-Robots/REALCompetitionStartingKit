Commit message: urdfs

File: realcomp/data/kuka_gripper_description/urdf/tomato.urdf (robot description, URDF)
Before this commit: robot tomato, 1 links, 0 joints
Links:
- link tomato: mass 1. -> 0.2
